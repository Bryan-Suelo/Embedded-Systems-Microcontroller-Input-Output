# Keil uVision project Leds.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Leds
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: startup_TM4C129.s LedBlink.c
    C:/Keil/ARM/Startup/TI/TM4C129/: system_TM4C129.c
